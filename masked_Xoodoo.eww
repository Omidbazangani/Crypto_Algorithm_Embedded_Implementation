<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Xoodoo_Masked.ewp</path>
    </project>
    <batchBuild />
</workspace>
