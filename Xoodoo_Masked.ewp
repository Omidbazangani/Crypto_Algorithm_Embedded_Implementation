# IAR project Xoodoo_Masked.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: E:\PhD_Works\Tron_Project\IAR_Projects\LPC1768_Xoodoo_masked\CMSIS\Include; E:\PhD_Works\Tron_Project\IAR_Projects\LPC1768_Xoodoo_masked\LIB\include; E:\PhD_Works\Tron_Project\IAR_Projects\LPC1768_Xoodoo_masked\SRC; E:\PhD_Works\Tron_Project\IAR_Projects\LPC1768_Xoodoo_masked\Xoodoo_LIB\Xoodoo_Abby
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: E:\PhD_Works\Tron_Project\IAR_Projects\LPC1768_Xoodoo_masked\CMSIS\Include; E:\PhD_Works\Tron_Project\IAR_Projects\LPC1768_Xoodoo_masked\LIB\include; E:\PhD_Works\Tron_Project\IAR_Projects\LPC1768_Xoodoo_masked\SRC
  OBJCOPY.OOCOutputFile: Xoodoo_Masked.srec
  ILINK.IlinkOutputFile: Xoodoo_Masked.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    LIB/source/: lpc17xx_clkpwr.c lpc17xx_gpio.c lpc17xx_libcfg_default.c lpc17xx_pinsel.c lpc17xx_uart.c
    CMSIS/Source/Templates/: system_LPC17xx.c
  group SRC
    SRC/: main.c peripherals.c
  group Xoodoo
    Xoodoo_LIB/Xoodoo_Abby/: ecrypt-sync.c xoodoo-masked-optimized.c
